# Keil uVision project RTOSDemo.uvproj, settings and files
target NUC1xx (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RTOSDemo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM0_NUC1xx
  c include: ..\..\Source\include;..\Common\include;..\CORTEX_NUC1xx_Keil_IAR;.\User_Demo\include;.\NUC1xxBSP\CMSIS\CM0;.\NUC1xxBSP\NuvotonPlatform_Keil\Include\Driver;.\NUC1xxBSP\NuvotonPlatform_Keil\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ./NUC1xxBSP/CMSIS/CM0/startup/arm/: startup_NUC1xx.s
    ./NUC1xxBSP/CMSIS/CM0/: core_cm0.c system_NUC1xx.c
  group Demo Files
    ./: main.c
    ./User_Demo/: Thread_Test.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM_CM0/: port.c
  group lib
    ./NUC1xxBSP/NuvotonPlatform_Keil/Src/Driver/: retarget.c
    ../../../Library/StdDriver/src/: clk.c gpio.c sys.c uart.c
